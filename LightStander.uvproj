# Keil uVision project LightStander.uvproj, settings and files
target LightStander (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0x0-0x0) IROM(0x0-0x1FFF) CLOCK(24000000)
  output: LightStander +hex
  c flags: Optimize=8
  c include: .\Sources\inc;.\Sources
  group Main
    ./Sources/: main.c
  group Drivers
    ./Sources/: adc.c oled.c random.c eeprom.c STC8G_H_ADC.c STC8G_H_EEPROM.c
  group App
    ./Sources/: modes.c keys.c display.c font_cn_16.c stop.c
